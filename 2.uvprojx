# Keil uVision project 2.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: AC78013FDLA AutoChips
  pack: AutoChips.AC780x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Board Support:AC780x Development Kit:Debug 1.0.0, Device:ATC Drivers:ACMP 1.0.0, Device:ATC Drivers:ADC 1.0.0, Device:ATC Drivers:CAN 1.0.0, Device:ATC Drivers:CKGEN 1.0.0, Device:ATC Drivers:CRC 1.0.0, Device:ATC Drivers:CTU 1.0.0, Device:ATC Drivers:DMA 1.0.0, Device:ATC Drivers:ECC SRAM 1.0.0, Device:ATC Drivers:GPIO 1.0.0, Device:ATC Drivers:I2C 1.0.0, Device:ATC Drivers:MMDIVSQART 1.0.0, Device:ATC Drivers:PWDT 1.0.0, Device:ATC Drivers:PWM 1.0.0, Device:ATC Drivers:RTC 1.0.0, Device:ATC Drivers:SPI 1.0.0, Device:ATC Drivers:SPM 1.0.0, Device:ATC Drivers:TIMER 1.0.0, Device:ATC Drivers:UART 1.0.0, Device:ATC Drivers:WDG 1.0.0, Device:ATC Drivers:eFlash 1.0.0, Device:Startup 1.0.0
